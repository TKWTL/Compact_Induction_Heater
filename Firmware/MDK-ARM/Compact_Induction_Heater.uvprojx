# Keil uVision project Compact_Induction_Heater.uvprojx, settings and files
target Compact_Induction_Heater (ARM-ADS)
  device: STM32G071CBTx STMicroelectronics
  cpu: IRAM(0x20000000-0x20008FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: Compact_Induction_Heater +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=48000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G071xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include
  group Application/MDK-ARM
    ./: startup_stm32g071xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c ucpd.c stm32g0xx_it.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_gpio.c stm32g0xx_ll_exti.c stm32g0xx_ll_pwr.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c stm32g0xx_ll_utils.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
software components: CMSIS:CORE 4.3.0
